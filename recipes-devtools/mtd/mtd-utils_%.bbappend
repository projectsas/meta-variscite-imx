FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://95633c4dfe943a701d4fcd809e6cabf4bf8710b8.patch"
